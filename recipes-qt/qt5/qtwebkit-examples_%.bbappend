FILESEXTRAPATHS_prepend := ":${THISDIR}/${PN}:"
SRC_URI += "file://browser-hide-ui.patch"
